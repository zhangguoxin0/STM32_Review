# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\System;.\Hardware;.\Hardware\LED;.\Driver;.\Driver\USART;.\Driver\SPI;.\Hardware\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group System
    ./System/: Systick.c Systick.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
  group Driver/USART
    ./Driver/USART/: usart.c usart.h
  group Driver/SPI
    ./Driver/SPI/: spi.c spi.h
  group Hardware/LED
    ./Hardware/LED/: bsp_led.c bsp_led.h
  group Hardware/Flash
    ./Hardware/FLASH/: w25q32.c w25q32.h
